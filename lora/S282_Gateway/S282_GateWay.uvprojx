# Keil uVision project S282_GateWay.uvprojx, settings and files
target S282 (ARM-ADS)
  device: GD32E103CB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.0
  cpu: IROM(0x08000000,0x020000) IRAM(0x20000000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S282_GateWay +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,GD32E103C_START
  c include: .\User;.\lib\Include;.\CMSIS;.\CMSIS\GD\GD32E10x\Include;.\Net\ENC28j60;.\Drive\lora;.\Drive\GPRS;.\Drive\Modbus;.\Drive\MQTT;.\Drive\ADC;.\Drive\CONFIG;.\Drive\FLASH;.\Drive\IWDG;.\Drive\IWDG;.\Drive\RTC;.\Drive\SPI;.\Drive\TIME;.\Drive\USRT;.\Net\Uip;.\Net\net;.\Net\Uip-app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./User/: gd32e10x_it.c gd32e103c_start.c main.c systick.c dealDat.c netLink.c
  group GPRS
    ./Drive/GPRS/: GprsNet.c GSM234G.c SMSInstruct.c
  group Net
    ./Net/net/: EthNet.c
    ./Net/ENC28j60/: enc28j60.c
  group Lora
    ./Drive/lora/: sx127x_Hal.c sx127x_Drive.c lora.c loraDealDat.c
  group Config
    ./Drive/CONFIG/: config.c config_interface.c
  group drive
    ./Drive/ADC/: Adc.c
    ./Drive/IWDG/: iwdg.c
    ./Drive/RTC/: rtc.c
    ./Drive/SPI/: spi.c
    ./Drive/USRT/: usart.c
    ./Drive/CONFIG/: hardware.c
    ./Drive/FLASH/: spi_flah.c sysFlash.c
    ./Drive/TIME/: tim2.c tim1.c
  group Modbus
    ./Drive/Modbus/: modbus.c modbusPub.c
  group MQTT
    ./Drive/MQTT/: MQTTUnsubscribeServer.c MQTTUnsubscribeClient.c MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTPacket.c MQTTFormat.c MQTTSerializePublish.c MQTTSubscribeServer.c MQTTSubscribeClient.c mqtt.c cJSON.c AliyunIOT.c HuaweiIOT.c MqttCouldPub.c
  group Uip
    ./Net/Uip/: timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c dhcpc.c
  group Uip_app
    ./Net/Uip-app/: clock-arch.c tapdev.c resolv.c uip_appcall.c udp_server.c udp_client.c tcp_server.c tcp_client.c
  group Startup
    ./User/: startup_gd32e10x.s
  group CMSIS
    ./CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E10x
    ./lib/Source/: gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_rcu.c gd32e10x_spi.c gd32e10x_dma.c gd32e10x_usart.c gd32e10x_bkp.c gd32e10x_rtc.c gd32e10x_fwdgt.c gd32e10x_exti.c gd32e10x_pmu.c gd32e10x_adc.c gd32e10x_timer.c
    ./lib/Include/: gd32e10x_fmc.c
  group Notes
    ./User/: Seq指令.txt
