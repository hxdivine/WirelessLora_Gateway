#include "uip_appcall.h"
#include "uip.h"	    
#include "enc28j60.h"
#include "resolv.h"
#include "Tapdev.h"
#include <STDIO.H>	
#include "dhcpc.h"

/*
	TCP应用接口函数(UIP_APPCALL)
*/
void tcp_appcall(void)
{
  	
	if(uip_conn->lport == HTONS(g_uiLintenPort))
	{//本地监听端口
		 tcp_server_appcall(); 
	}		    

	//远程连接端口
	if(g_mconn[0].port != 0 && g_mconn[0].port != 0xffff)
	{
		if(HTONS(g_mconn[0].port) == uip_conn->rport)
		{
			tcp_client_appcall();
		}
	}
	if(g_mconn[1].port != 0 && g_mconn[1].port != 0xffff)
	{
		if(HTONS(g_mconn[1].port) == uip_conn->rport)
		{
			tcp_client_appcall();
		}
	}
//	resolv_appcall();
}
/*
	udp回调函数
*/
void udp_appcall(void)
{
	if(g_mconn[0].port != 0 && g_mconn[0].port != 0xffff)
	{
		if(uip_udp_conn->rport == HTONS(g_mconn[0].port))
		{
			udp_client_appcall();
		}
	}
	if(g_mconn[1].port != 0 && g_mconn[1].port != 0xffff)
	{
		if(uip_udp_conn->rport == HTONS(g_mconn[1].port))
		{
			udp_client_appcall();
		}
	}
	
	resolv_appcall();
	switch(uip_udp_conn->rport)	//远程连接1500端口
	{
		case HTONS(67):
		case HTONS(68):
			dhcpc_appcall();
			break;
		default: 
			break;
	}
}
/*
	log日志
*/
void uip_log(char *m)
{			    
	//printf("uIP log:%s\r\n",m);
}
