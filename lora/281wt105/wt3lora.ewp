# IAR project wt3lora.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; 
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 281wt2_18b20.hex
  ILINK.IlinkOutputFile: 281wt2.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group fwlib
    ../fwlib/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_tim1.c stm8l15x_usart.c
  group user
    ./: 18b20.c flash_eeprom.c hw_config.c it.c main.c pccmd.c Rf433.c
    lora/: lora.c SX127X_Driver.c SX127X_Hal.c
