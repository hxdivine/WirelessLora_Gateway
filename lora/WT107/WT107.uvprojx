# Keil uVision project WT107.uvprojx, settings and files
target WT107 (ARM-ADS)
  device: HC32L130E8PA HDSC
  pack: HDSC.HC32L130.1.0.1
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: WT107 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\User;.\RTE;.\hardware;.\RTE\Device\HC32L130E8PA;.\driver\inc;.\hardware\lora;.\hardware\Sensor
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./User/: main.c system_hc32l13x.c interrupts_hc32l13x.c
  group STARTUP
    ./User/: startup_hc32l13x.s
  group LIB
    ./driver/src/: ddl.c flash.c gpio.c i2c.c spi.c sysctrl.c timer3.c uart.c bt.c wdt.c
  group HARDWARE
    ./hardware/: hardware.c HC_Flash.c HC_I2c.c HC_Spi.c HC_Time3.c HC_Usart.c HC_Tim.c HC_Wdt.c
  group LORA
    ./hardware/lora/: lora.c loraDealDat.c sx127x_Drive.c sx127x_Hal.c
  group CONFIG
    ./hardware/: SysConfig.c
  group SENSOR
    ./hardware/Sensor/: BH1750.c Gxht3L.c Sgp30.c Soil.c
